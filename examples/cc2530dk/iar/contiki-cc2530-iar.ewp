# IAR project contiki-cc2530-iar.ewp, settings and files
configuration Debug (8051, debug)
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\CC2530F256.i51
  ICC8051.CCDefines: XLIREN; MODEL_CC2531=0; AUTOSTART_ENABLE=1; UIP_CONF_IPV6=1
  ICC8051.CCDiagSuppress: Pa050
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCIncludePath2: ..\..\..\core\; ..\..\..\cpu\cc253x\; ..\..\..\platform\cc2530dk\
  ICC8051.CCStdIncludePath: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\CLIB\
  ICC8051.CCOptLevel: 3
  ICC8051.CCOptStrategy: 0
  XLINK.XclFile: f8w2530.xcl
configuration Release (8051)
  as the first configuration, except:
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\devices\
  General.RTConfigPath: xxx.h
  ICC8051.CCDefines: NDEBUG
  XLINK.XclFile: lnk0t.xcl
  group core/dev
    ../../../core/dev/: cc2420-aes.c cc2420.c cc2520.c ds2411.c leds.c nullradio.c serial-line.c sht11-sensor.c sht11.c slip.c
  group core/lib
    ../../../core/lib/: assert.c checkpoint.c crc16.c ctk-filedialog.c ctk-textentry-checkbox.c ctk-textentry-cmdline.c ctk-textentry-multiline.c gcr.c ifft.c libconio.c list.c me.c me_tabs.c memb.c mmem.c petsciiconv.c print-stats.c random.c ringbuf.c sensors.c strncasecmp.c
  group core/net
    ../../../core/net/: dhcpc.c hc.c neighbor-attr.c neighbor-info.c netstack.c packetbuf.c packetqueue.c psock.c queuebuf.c rawpacket-udp.c resolv.c sicslowpan.c simple-udp.c slipdev.c tcpdump.c tcpip.c uaodv-rt.c uaodv.c uip-debug.c uip-ds6.c uip-fw-drv.c uip-fw.c uip-icmp6.c uip-nd6.c uip-neighbor.c uip-over-mesh.c uip-packetqueue.c uip-split.c uip-udp-packet.c uip.c uip6.c uip_arp.c uiplib.c
  group core/net/mac
    ../../../core/net/mac/: contikimac.c csma.c ctdma_mac.c cxmac.c frame802154.c framer-802154.c framer-nullmac.c lpp.c mac.c nullmac.c nullrdc-noframer.c nullrdc.c phase.c sicslowmac.c tdma_mac.c xmac.c
  group core/net/rime
    ../../../core/net/rime/: abc.c announcement.c broadcast-announcement.c broadcast.c chameleon-bitopt.c chameleon-raw.c chameleon.c channel.c collect-link-estimate.c collect-neighbor.c collect.c ipolite.c mesh.c multihop.c neighbor-discovery.c netflood.c polite-announcement.c polite.c rime-udp.c rime.c rimeaddr.c rimestats.c rmh.c route-discovery.c route.c rucb.c rudolph0.c rudolph1.c rudolph2.c runicast.c stbroadcast.c stunicast.c timesynch.c trickle.c unicast.c
  group core/net/rpl
    ../../../core/net/rpl/: rpl-dag.c rpl-ext-header.c rpl-icmp6.c rpl-of-etx.c rpl-of0.c rpl-timers.c rpl.c
  group core/sys
    ../../../core/sys/: arg.c autostart.c compower.c ctimer.c energest.c etimer.c mt.c process.c procinit.c profile-aggregates.c profile.c rtimer.c stimer.c timer.c timetable-aggregate.c timetable.c
  group cpu/cc253x
    ../../../cpu/cc253x/: rtimer-arch.c soc.c stack.c
  group cpu/cc253x/dev
    ../../../cpu/cc253x/dev/: cc2530-rf.c clock.c dma.c dma_intr.c random.c uart-intr.c uart0.c uart1.c watchdog.c
  group examples/cc2530dk
    ../: hello-world.c
  group platform/cc2530dk
    ../../../platform/cc2530dk/: contiki-main.c debug.c putchar.c viztool.c
  group platform/cc2530dk/dev
    ../../../platform/cc2530dk/dev/: adc-sensor.c button-sensor.c leds-arch.c slip-arch.c smartrf-sensors.c
