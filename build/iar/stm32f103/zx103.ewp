# IAR project zx103.ewp, settings and files
configuration Normal (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Full.h
  General.OGChipSelectEditMenu: STM32F10xxB ST STM32F10xxB
  ICCARM.CCDefines: STM32F10X_MD; MCK=72000000; WITH_IPV6; WITH_SLIP_NET
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: $TOOLKIT_DIR$\arm\inc; ..\..\..\core; ..\..\..\core\sys; ..\..\..\core\lib; ..\..\..\core\net; ..\..\..\cpu\arm\stm32f10x; ..\..\..\platform\stm32f10x; ..\..\..\cpu\arm\stm32f10x\STM32F10x_StdPeriph_Lib_V3.5.0\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x; ..\..\..\cpu\arm\stm32f10x\STM32F10x_StdPeriph_Lib_V3.5.0\Libraries\CMSIS\CM3\CoreSupport; ..\..\..\cpu\arm\stm32f10x\STM32F10x_StdPeriph_Lib_V3.5.0\Libraries\STM32F10x_StdPeriph_Driver\inc
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ILINK.IlinkOutputFile: zx103.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration 6lowpan (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: STM32F10X_MD; MCK=72000000; WITH_IPV6; WITH_SLIP_NET; WITH_II_802154
configuration 6lowpan-rpl (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: STM32F10X_MD; MCK=72000000; WITH_IPV6; WITH_SLIP_NET; WITH_II_802154; WITH_RPL; WITH_RPL_APP
  ICCARM.CCIncludePath2: $TOOLKIT_DIR$\arm\inc; ..\..\..\core; ..\..\..\core\sys; ..\..\..\core\lib; ..\..\..\core\net; ..\..\..\core\net\rpl; ..\..\..\cpu\arm\stm32f10x; ..\..\..\platform\stm32f10x; ..\..\..\cpu\arm\stm32f10x\STM32F10x_StdPeriph_Lib_V3.5.0\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x; ..\..\..\cpu\arm\stm32f10x\STM32F10x_StdPeriph_Lib_V3.5.0\Libraries\CMSIS\CM3\CoreSupport; ..\..\..\cpu\arm\stm32f10x\STM32F10x_StdPeriph_Lib_V3.5.0\Libraries\STM32F10x_StdPeriph_Driver\inc
  group core/dev
    ../../../core/dev/: leds.c nullradio.c slip.c
  group core/lib
    ../../../core/lib/: assert.c crc16.c ctk-filedialog.c ctk-textentry-checkbox.c ctk-textentry-cmdline.c ctk-textentry-multiline.c gcr.c ifft.c libconio.c list.c me.c me_tabs.c memb.c mmem.c petsciiconv.c print-stats.c random.c ringbuf.c sensors.c strncasecmp.c
  group core/net
    ../../../core/net/: dhcpc.c hc.c neighbor-attr.c neighbor-info.c netstack.c packetbuf.c packetqueue.c psock.c queuebuf.c rawpacket-udp.c resolv.c sicslowpan.c simple-udp.c slipdev.c tcpdump.c tcpip.c uaodv-rt.c uaodv.c uip-debug.c uip-ds6.c uip-fw-drv.c uip-fw.c uip-icmp6.c uip-nd6.c uip-neighbor.c uip-over-mesh.c uip-packetqueue.c uip-split.c uip-udp-packet.c uip.c uip6.c uip_arp.c uiplib.c
  group core/net/mac
    ../../../core/net/mac/: contikimac.c nullmac.c
  group core/net/rime
    ../../../core/net/rime/: rimeaddr.c
  group core/net/rpl
    ../../../core/net/rpl/: rpl-dag.c rpl-ext-header.c rpl-icmp6.c rpl-of-etx.c rpl-of0.c rpl-timers.c rpl.c
  group core/sys
    ../../../core/sys/: arg.c autostart.c compower.c ctimer.c energest.c etimer.c mt.c process.c procinit.c profile-aggregates.c profile.c rtimer.c stimer.c timer.c timetable-aggregate.c timetable.c
  group cpu/arm/stm32f10x
    ../../../cpu/arm/stm32f10x/: clock.c
  group cpu/arm/stm32f10x/dev
    ../../../cpu/arm/stm32f10x/dev/: uart1.c uart2.c
  group cpu/arm/stm32f10x/STM32F10x_StdPeriph_Lib/CMSIS
    ../../../cpu/arm/stm32f10x/STM32F10x_StdPeriph_Lib_V3.5.0/Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../../../cpu/arm/stm32f10x/STM32F10x_StdPeriph_Lib_V3.5.0/Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/iar/: startup_stm32f10x_md_vl.s
    ../../../cpu/arm/stm32f10x/STM32F10x_StdPeriph_Lib_V3.5.0/Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group cpu/arm/stm32f10x/STM32F10x_StdPeriph_Lib/lib
    ../../../cpu/arm/stm32f10x/STM32F10x_StdPeriph_Lib_V3.5.0/Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c
  group example/hello-world
    ../../../examples/hello-world/: hello-world.c
  group platform/stm32f10x
    ../../../platform/stm32f10x/: contiki-main.c
  group platform/stm32f10x/dev
    ../../../platform/stm32f10x/dev/: slip-arch.c slip-net-6lowpan.c slip-net.c
  group zonesion/rpl
    ../../../zonesion/rpl/: apprpl.c
